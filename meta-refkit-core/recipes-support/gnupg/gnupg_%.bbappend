# TODO: submit to OE-core
BBCLASSEXTEND_append_refkit-config = "native nativesdk"
